File: pcb_files_v2/power_world.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U2 4069, U6 4081, U9 4066

Commit message: oct 2025 update
Other:
- note added: "POWER for CHIPS"
